# Keil uVision project 4ch_pro.uvprojx, settings and files
target 4ch_pro (6120000::V6.12::.\ARMCLANG)
  device: STM32F030C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: 4ch_pro +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030x6
  c include: ..\Inc;..\Drivers\STM32F0xx_HAL_Driver\Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\MyHome
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group MyHome
    ../MyHome/: ChControl.cpp
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 5.3.0

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\4ch_pro.ewp</path>
  </project>
  <batchBuild />
</workspace>
